# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Fire_RT-Thread
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finish;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c rtconfig.h
  group rtt/port
    ../rtthread/3.0.3/include/: rthw.h
    ../rtthread/3.0.3/libcpu/arm/cortex-m4/: cpuport.c
  group rtt/sourse
    ../rtthread/3.0.3/include/: rtdef.h rtthread.h rtservice.h
    ../rtthread/3.0.3/src/: thread.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
